options:
  parameters:
    author: user
    generate_options: qt_gui
    id: short
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: noise_mean
  id: variable
  parameters:
    value: '0'
  states: {}
- name: noise_power
  id: variable
  parameters:
    value: '100'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '30720000'
  states: {}
- name: zmq_vector_len
  id: variable
  parameters:
    value: '61440'
  states: {}
- name: analog_noise_source_x_1_0
  id: analog_noise_source_x
  parameters:
    amp: np.sqrt(noise_power)
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: blocks_add_const_vxx_0_0
  id: blocks_add_const_vxx
  parameters:
    const: noise_mean
    type: complex
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '1.0'
    vector_output: 'False'
  states: {}
- name: blocks_interleaved_short_to_complex_0
  id: blocks_interleaved_short_to_complex
  parameters:
    scale_factor: '1.0'
    vector_input: 'False'
  states: {}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: zmq_vector_len
    type: short
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: zmq_vector_len
    type: short
  states: {}
- name: channel_simulator_channelModel_0
  id: channel_simulator_channelModel
  parameters:
    decimation: '4'
    taps: '[1.0]'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: '"channel_in"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '32768'
    name: '"channel_out"'
    type: complex
    update_time: '0.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"channel_in"'
    size: '1000000'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"channel_out"'
    size: '1000000'
    srate: samp_rate
    type: complex
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '4'
    taps: '[1, 1, 1, 1]'
    type: ccc
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: channel_out
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: awgn_out
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: channel_in
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: awgn_in
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: awgn_in
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: awgn_out
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: channel_in
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: channel_out
  states: {}
- name: zeromq_pull_source_0
  id: zeromq_pull_source
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
    type: short
    vlen: zmq_vector_len
  states: {}
- name: zeromq_push_sink_0_0_0_0_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:5558
    timeout: '100'
    type: short
    vlen: zmq_vector_len
  states: {}

connections:
- [analog_noise_source_x_1_0, '0', blocks_add_xx_1_0, '0']
- [blocks_add_const_vxx_0_0, '0', virtual_sink_1, '0']
- [blocks_add_xx_1_0, '0', blocks_add_const_vxx_0_0, '0']
- [blocks_complex_to_interleaved_short_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_interleaved_short_to_complex_0, '0', blocks_throttle2_0, '0']
- [blocks_stream_to_vector_1, '0', zeromq_push_sink_0_0_0_0_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle2_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle2_0, '0', virtual_sink_2, '0']
- [blocks_vector_to_stream_0, '0', blocks_interleaved_short_to_complex_0, '0']
- [channel_simulator_channelModel_0, '0', qtgui_freq_sink_x_0_0, '0']
- [channel_simulator_channelModel_0, '0', qtgui_time_sink_x_0_0, '0']
- [channel_simulator_channelModel_0, '0', virtual_sink_0, '0']
- [rational_resampler_xxx_0, '0', channel_simulator_channelModel_0, '0']
- [virtual_source_0, '0', blocks_add_xx_1_0, '1']
- [virtual_source_1, '0', blocks_complex_to_interleaved_short_0, '0']
- [virtual_source_2, '0', rational_resampler_xxx_0, '0']
- [virtual_source_3, '0', virtual_sink_3, '0']
- [zeromq_pull_source_0, '0', blocks_vector_to_stream_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.7.0
